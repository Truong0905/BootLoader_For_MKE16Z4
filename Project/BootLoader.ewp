# IAR project BootLoader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE16Z64xxx4 NXP MKE16Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKE16Z64VLF4
  ICCARM.CCIncludePath2: C:\Users\999va\OneDrives\Desktop\FPT\NXP\Mock\CMSIS\Include; C:\Users\999va\OneDrives\Desktop\FPT\NXP\Mock\MKE16Z4; C:\Users\999va\OneDrives\Desktop\FPT\NXP\Mock\Queue; C:\Users\999va\OneDrives\Desktop\FPT\NXP\Mock\Srec; C:\Users\999va\OneDrives\Desktop\FPT\NXP\Mock\Driver\inc; C:\Users\999va\OneDrives\Desktop\FPT\NXP\Mock\Boot
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BootLoader.srec
  ILINK.IlinkOutputFile: BootLoader.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Boot
    ../Boot/: boot.c boot.h
  group Driver/Inc
    ../Driver/inc/: clocking.h fgpio.h FLASH.h LPUART.h port.h
  group Driver/Src
    ../Driver/src/: clocking.c fgpio.c FLASH.c LPUART.c port.c
  group Queue
    ../Queue/: queue.c queue.h
  group Source
    ../Source/: main.c
  group Srec
    ../Srec/: srec.c srec.h
  group Startup
    ../MKE16Z4/: startup_MKE16Z4.s system_MKE16Z4.c system_MKE16Z4.h
